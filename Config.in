## Config.in
```kconfig
config BR2_PACKAGE_SYSTEM_CONTROL
    bool "aml system control"
    default y
    depends on BR2_LINUX_KERNEL
    help
        system control
```
